PACKAGECONFIG_append = " sql-mysql sql-sqlite "
