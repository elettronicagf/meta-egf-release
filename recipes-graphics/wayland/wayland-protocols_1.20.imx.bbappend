SRC_URI = "${IMX_LIBDRM_SRC};branch=${IMX_LIBDRM_BRANCH}"
SRCREV = "9cacf108d0ee5863c7a656da5d2271bc2396e43d"
LIC_FILES_CHKSUM = "file://COPYING;md5=c7b12b6702da38ca028ace54aae3d484"
IMX_LIBDRM_SRC =   "git://github.com/nxp-imx/wayland-protocols-imx.git;protocol=https;nobranch=1"

