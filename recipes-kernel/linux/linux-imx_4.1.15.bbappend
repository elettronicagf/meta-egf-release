

KERNEL_SRC = "git://source.codeaurora.org/external/imx/linux-imx.git;protocol=https"








