KERNEL_SRC = "git://github.com/nxp-imx/linux-imx.git;protocol=https"
LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
SRCREV = "ef3f2cfc6010c13feb40cfb7fd7490832cf86f45"

