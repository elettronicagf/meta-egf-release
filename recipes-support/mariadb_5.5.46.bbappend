#add SSL support
EXTRA_OECMAKE += "-DWITH_SSL=system"
